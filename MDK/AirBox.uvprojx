# Keil uVision project AirBox.uvprojx, settings and files
target Airbox (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AirBox
  AfterMake: fromelf  --bin  -o ./Objects/AirBox.bin ./Objects/AirBox.axf
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\source;..\driver\inc;..\common;G:\Keil_v5\ARM\PACK\ARM\CMSIS\5.7.0\CMSIS\Core\Include;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group HARDWARE
    ../HARDWARE/: lcd.c sc09.c uart_pm.c
  group source
    ../source/: main.c airbox.c mcu_api.c protocol.c system.c
  group common
    ../common/: interrupts_hc32l13x.c system_hc32l13x.c startup_hc32l13x.s
  group driver
    ../driver/src/: ddl.c gpio.c i2c.c sysctrl.c uart.c lpuart.c timer3.c bt.c flash.c wdt.c
software components: CMSIS:CORE 5.4.0
